Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification - Nom du type: Pointe 8 mm; Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm; Nom de la famille: Niveau
Contraintes - Elévation: 0 mm; Base de l'élévation: Point de base du projet
Cotes - Hauteur de calcul: 0 mm

# IfcBuildingElementProxy, 55b8f13f-218f-404a-b919-619bea281124:55b8f13f-218f-404a-b919-619bea281124:201811
In: Niveau 1
Type - Material: Plate
Type - Autre - Catégorie: Equipement spécialisé
Type - Données d'identification - Coût: 0; Description: CHEMINEE ETHANOL; Fabricant: FOCUS; Modèle: GIROFOCUS BIOETHANOL; Numéro OmniClass: 23.40.20.34.14; Titre OmniClass: Fireplaces; URL: https://www.focus-creation.com/gyrofocus-bioethanol
Pset_ManufacturerTypeInformation - Manufacturer: FOCUS
Autre - Famille: 55b8f13f-218f-404a-b919-619bea281124: 55b8f13f-218f-404a-b919-619bea281124; Famille et type: 55b8f13f-218f-404a-b919-619bea281124: 55b8f13f-218f-404a-b919-619bea281124; ID du type: 55b8f13f-218f-404a-b919-619bea281124: 55b8f13f-218f-404a-b919-619bea281124; Type: 55b8f13f-218f-404a-b919-619bea281124: 55b8f13f-218f-404a-b919-619bea281124
Contraintes - Décalage: 0 mm; Hôte: Aucun(e)
Cotes - Surface: 6.69507 m2; Volume: 3.20471 m3
Phase de construction - Phase de création: Nouvelle construction
